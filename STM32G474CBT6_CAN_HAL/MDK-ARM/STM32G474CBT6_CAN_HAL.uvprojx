# Keil uVision project STM32G474CBT6_CAN_HAL.uvprojx, settings and files
target STM32G474CBT6_CAN_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474CBT6_CAN_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/SM;./User;../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/Std_Expand;./SM;./Hardware
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c gpio.c fdcan.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group SM/Display
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/SM/Display/: Character_display.c Character_display.h Display_core.c Display_core.h
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/SM/Font/: Ascii_font.c Ascii_font.h
  group SM/Control
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/SM/Control/: Control_core.c Control_core.h
  group SM/Menu_Core
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/SM/Menu_Core/: Menu_core.c Menu_core.h
  group SM/Menu_Page
    ./SM/Menu_Page/: Menu_peripheral.c Menu_peripheral.h
  group User
    ./User/Project/: Project.c Project.h
    ./User/System/: System.c System.h
  group std_Expand
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/Std_Expand/Math_Expand/: math_Expand.c math_Expand.h
    ../../../SM_MenuSystem/STM32F446RCT6_Guitarist_CUBEMX/MDK-ARM/Std_Expand/Stdint_Expand/: stdint_Expand.c stdint_Expand.h
  group Hardware
    ./Hardware/: CAN_Expand.c CAN_Expand.h
software components: CMSIS:CORE 6.1.0
